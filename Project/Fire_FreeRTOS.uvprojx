# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32G031K8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\freertos\Source\include
  asm include: ..\freertos\Source\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ../User/: main.c
  group FreeRTOS/Source
    ../freertos/Source/include/: list.h portmacro.h FreeRTOSConfig.h
    ../freertos/: list.c
  group doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.4.0, Device:Startup 1.3.0
